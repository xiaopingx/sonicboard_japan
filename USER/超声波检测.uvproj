# Keil uVision project 超声波检测.uvproj, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: Mini54FDE Nuvoton
  cpu: IRAM(0x20000000-0x200007FF) IROM(0-0x3FFF) CLOCK(24000000) CPUTYPE("Cortex-M0")
  output: 超声波检测 +hex
  AfterMake: fromelf --bin "..\OBJ\@L.axf" --output "..\OBJ\@L.bin"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\CHAR;..\HARDWARE\WATCHDOG;..\HARDWARE\EEPROM;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  link misc: --entry Reset_Handler
  group Source Group 1
    ./: startup_Mini51Series.s
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/CHAR/: hardware.c
    ../HARDWARE/EEPROM/: mini51eeprom.c
    ../HARDWARE/WATCHDOG/: watchdog.c
    ../HARDWARE/TIMER/: timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: clk.c mini51_nvic.c sys.c system_Mini51Series.c
